DEPENDS += " rdk-wifi-halif"
